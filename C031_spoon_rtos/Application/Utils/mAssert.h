/*******************************************************************************
** @file:      	mAssert.h
** @author:    	HUY DAI
** @version:   	V1.0.0
** @time:      	11:12 AM Monday, October 21, 2019
** @brief:	 	
** @revision:	
**             	- version 1.0.1: <date> <name>
**             	<discribe the change>
*******************************************************************************/

#ifndef _M_ASSERT_H_
#define _M_ASSERT_H_
/*******************************************************************************
**                               INCLUDES
*******************************************************************************/
#include <stdint.h>
#include <stdlib.h>
#include <stdio.h>
#include "string.h"
/*******************************************************************************
**                               COMMON DEFINES
*******************************************************************************/



/*******************************************************************************
**                               DEBUG FUNCTION DEFINES
*******************************************************************************/

/*******************************************************************************
**                               DELAY FUNCTION DEFINES
*******************************************************************************/

/*******************************************************************************
**                               ASSERT DEFINES
*******************************************************************************/
#define ASSERT_VOID(con)            {\
		                                if(!(con))\
		                                {\
		                                    LREP("ASSERT file %s line %d\r\n",\
		                                    		__FILE__, __LINE__);\
		                                    return;\
		                                }\
                                    }

#define ASSERT_NONVOID(con, ret)    {\
                                        if(!(con))\
                                        {\
                                            LREP("ASSERT file %s line %d\r\n",\
                                                    __FILE__, __LINE__);\
                                            return ret;\
                                        }\
                                    }

#ifndef ASSERT
#define ASSERT(con)                 {\
		                                if(!(con))\
		                                {\
		                                    LREP("\r\nASSERT file %s line %d\r\n",\
		                                        __FILE__, __LINE__);\
		                                }\
                                    }

#define ASSERT_VALUE(con, val)      {\
		                                if(!(con))\
		                                {\
		                                    LREP("\r\nASSERT file %s line %d, val = %d\r\n",\
		                                            __FILE__, __LINE__, val);\
		                                }\
                                    }
#endif
	
#define ASSERT_WARN(con)            {\
		                                if(!(con))\
		                                {\
		                                    LREP("\r\nASSERT file %s line %d.",\
		                                            __FILE__, __LINE__);\
		                                }\
    `                               }


/*******************************************************************************
**                               ENUM RETURN STATUS DEFINES
*******************************************************************************/


/*******************************************************************************
**                               COMMON DEFINES
*******************************************************************************/



#endif 

/******************************** End of file *********************************/
